# Keil uVision project STC8G-H-LIB.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8G-H-LIB +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Driver\inc;..\User;..\App\inc;..\OLED
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c system_init.c Task.c isr.asm
  group APP
    ../App/src/: APP.c APP_AD_UART2.c APP_INT_UART1.c APP_Lamp.c APP_RTC.c APP_I2C_PS.c APP_SPI_PS.c APP_WDT.c APP_EEPROM.c APP_PWMA_Output.c APP_PWMB_Output.c APP_PCA_PWM.c APP_PCA_Capture.c APP_PWM15bit.c
  group Driver
    ../Driver/src/: STC8G_H_ADC.c STC8G_H_Compare.c STC8G_H_Delay.c STC8G_H_EEPROM.c STC8G_H_Exti.c STC8G_H_GPIO.c STC8G_H_I2C.c STC8G_H_Timer.c STC8G_H_UART.c STC8G_PCA.c STC8G_PWM15bit.c STC8H_PWM.c STC8G_H_SPI.c STC8G_H_Soft_I2C.c STC8G_H_Soft_UART.c STC8G_H_WDT.c STC8G_H_NVIC.c STC8H_RTC.c
  group ISR
    ../Driver/isr/: STC8G_H_ADC_Isr.c STC8G_H_Compare_Isr.c STC8G_H_Exti_Isr.c STC8G_H_GPIO_Isr.c STC8G_H_I2C_Isr.c STC8G_H_Timer_Isr.c STC8G_H_UART_Isr.c STC8G_PCA_Isr.c STC8G_PWM15bit_Isr.c STC8H_PWM_Isr.c STC8G_H_SPI_Isr.c STC8H_RTC_Isr.c
  group OLED
    ../OLED/: oled.c oled.h oledfont.h oledpic.h
